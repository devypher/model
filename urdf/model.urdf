Commit message: Modified URDF file

File: urdf/model.urdf (robot description, URDF)
Before this commit: robot model, 6 links, 5 joints
Joints:
- joint lidarjoint: origin xyz=-0.29589 -0.15066 0.011838 rpy=0 3.14 0 -> xyz=-0.29589 -0.15066 0.011838 rpy=0 0 0
